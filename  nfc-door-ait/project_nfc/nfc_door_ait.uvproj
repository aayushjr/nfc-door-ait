# Keil uVision project nfc_door_ait.uvproj, settings and files
target Target (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: nfc_door_ait
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\inc;.\libs\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ./src/: startup_stm32f051.s system_stm32f0xx.c
  group std_periph_driver
    ./libs/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_tim.c
  group main
    ./main_nfc/: main_nfc.c
  group hal
    ./src/: util.c sic4310.c servolib.c
    ./: protocol.c
